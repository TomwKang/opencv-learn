# Keil uVision project sentry_gimbal_2019.uvprojx, settings and files
target sentry_gimbal_2019 (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Scu_Rm2018 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\include\bsp;..\include\main_task;..\include\system;..\DSP\Include;..\MPU6500;..\USMART;..\include\communication;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\TASK\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.cpp
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_can.c stm32f4xx_spi.c fifo.h RMLib.lib stm32f4xx_adc.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
  group BSP
    ../src/bsp/: adc.c beep.c key.c led.c can1.c can2.c dbus.c gun.c laser.c spi.c timer.c usart2.c usart3.c imu.c power.c kalman_filter.c auto_aim.c bsp.cpp com_usart.cpp
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group SYSTEM
    ../src/system/: delay.c sys.c visualscope.c pid_regulator.c ramp.c flags.c debug_pid.c
    ../src/communication/: MSB64Decoder.c MSB64Encoder.c MSMD5Encoder.c ModuleSerial.cpp communication.cpp
  group MAIN_TASK
    ../src/main_task/: can_bus_task.c remote_task.c minipc_task.cpp control_task.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_TASK
    ../TASK/src/: control_RTOS_Task.c init_task.c minipc_RTOS_Task.c main_RTOS_Task.cpp
